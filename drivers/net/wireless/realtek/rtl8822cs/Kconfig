## drivers/net/wireless/realtek/rtl8822cs/Kconfig
```kconfig
config RTL8822BS
	tristate "Realtek 8822CS SDIO WiFi"
	help
	  Help message of RTL8822CS
```
